options:
  parameters:
    author: ipsit
    description: Equalization
    generate_options: qt_gui
    id: lab1_task3
    output_language: python
    title: Lab 1 Task 3
  states: {}

blocks:
- name: band1
  id: variable_qtgui_range
  parameters:
    label: 20Hz - 500Hz
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: slider
  states: {}
- name: band2
  id: variable_qtgui_range
  parameters:
    label: 500Hz - 3kHz
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: slider
  states: {}
- name: band3
  id: variable_qtgui_range
  parameters:
    label: 3kHz - 6kHz
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: slider
  states: {}
- name: band4
  id: variable_qtgui_range
  parameters:
    label: 6kHz - 9kHz
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: slider
  states: {}
- name: band5
  id: variable_qtgui_range
  parameters:
    label: 9kHz - 15kHz
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    gain: band1
    high_cutoff_freq: '500'
    interp: '1'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10'
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: band5
    high_cutoff_freq: '15000'
    low_cutoff_freq: '9000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: band4
    high_cutoff_freq: '9000'
    low_cutoff_freq: '6000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_3
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: band3
    high_cutoff_freq: '6000'
    low_cutoff_freq: '3000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_4
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: band2
    high_cutoff_freq: '3000'
    low_cutoff_freq: '500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_KAISER
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/ipsit/Documents/EE 340/Lab 1/equalizer.wav
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ipsit/Documents/EE 340/Lab 1/Bach.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_1, '0', blocks_add_xx_0, '4']
- [band_pass_filter_2, '0', blocks_add_xx_0, '3']
- [band_pass_filter_3, '0', blocks_add_xx_0, '2']
- [band_pass_filter_4, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_1, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_2, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_3, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_4, '0']

metadata:
  file_format: 1
