options:
  parameters:
    author: ipsit
    description: Coherently combining Music Signals
    generate_options: qt_gui
    id: lab1_task2
    output_language: python
    title: Lab 1 Task 2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/ipsit/Documents/EE 340/Lab 1/voice_n_background.wav
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ipsit/Documents/EE 340/Lab 1/vocal.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/ipsit/Documents/EE 340/Lab 1/background.wav
    repeat: 'True'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '320'
    fbw: '0.4'
    interp: '441'
    taps: ''
    type: fff
  states: {}

connections:
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
